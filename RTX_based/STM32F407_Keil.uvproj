# Keil uVision project STM32F407_Keil.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F407_Keil +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o ./controller.bin ./Object/STM32F407_Keil.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\User_Code\Header;.\Libraries\eth;.\User_Code\Core\RTX_CAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ./: startup_stm32f4xx.s
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Source
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_it.c stm32f4xx_can.c
    ./User_Code/Source/: Can.c Device_Init.c Global.c Main.c Usart.c flash.c spi.c DBase.c I2C.c Task.c Schedule.c First_Start.c Analyse.c Guodu.c Collide.c Data_solution_lm.c RT_operate_lxb.c DB_meng.c find_sche_lxb.c phase_output_lxb.c led.c marix_keyboard.c
  group Header
    ./User_Code/Header/: Can.h Device_Init.h Usart.h Include.h flash.h spi.h DBase.h I2C.h Task.h Schedule.h First_Start.h System_Control.h Analyse.h Guodu.h Collide.h
  group rtx config
    ./User_Code/Core/: RTX_Conf_CM.c
  group eth config
    ./eth config/: Net_Config.c
    ./Libraries/eth/: ETH_STM32F4xx.c
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib TCPD_CM3.lib
  group CAN config
    ./User_Code/Core/RTX_CAN/: CAN_Cfg.h CAN_STM32F40x.c RTX_CAN.c RTX_CAN.h
